# Keil uVision project servo_controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C58 SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(33000000)
  output: servo_controller +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ./src/include
  group lcm
    ./src/lcm/: lcm.c
  group stc
    ./src/stc/: delay.c
  group main
    ./src/: main.c
